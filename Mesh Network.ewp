# IAR project Mesh Network.ewp, settings and files
configuration Master (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430g2553.xcl
  XLINK.XlinkStackSize: 1
configuration Slave (MSP430, debug)
  as the first configuration, except:
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430.xcl
  group (top)
    Source/: Config.h delay.h Hal_2533.h main.c Mesh.h onewire.h RF_CC1101_2533.h
    Lib/: Mesh Network G2533 - Master.lib Mesh Network G2533 - Slave.lib
